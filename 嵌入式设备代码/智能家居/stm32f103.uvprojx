# Keil uVision project stm32f103.uvprojx, settings and files
target STM32F103 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: stm32f103 +hex
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_MD, USE_STDPERIPH_DRIVER
  c include: .\core;.\fwlib\inc;.\hardware\inc;.\user;.\NET\onenet\inc;.\NET\MQTT;.\NET\device\inc;.\hardware;.\NET\CJSON
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group core
    ./core/: core_cm3.c stm32f10x_it.c system_stm32f10x.c
    ./core/startup/arm/: startup_stm32f10x_md.s
    ./fwlib/src/: stm32f10x_exti.c
  group fwlib
    ./fwlib/src/: misc.c stm32f10x_gpio.c stm32f10x_usart.c stm32f10x_adc.c stm32f10x_tim.c stm32f10x_flash.c
  group hardware
    ./fwlib/src/: stm32f10x_rcc.c
    ./hardware/src/: delay.c usart.c Led.c key.c dht11.c sys.c OLED.c mq2.c buzzer.c adcx.c Servo.c PWM.c Motor.c LightSensor.c MFRC522.c KEY1.c flash.c OLED_Data.c
  group user
    ./user/: main.c
  group OneNET
    ./NET/onenet/src/: onenet.c hmac_sha1.c base64.c
  group net_protocol
    ./NET/MQTT/: MqttKit.c
  group net_device
    ./NET/device/src/: esp8266.c
  group CJSON
    ./NET/CJSON/: cJSON.c
software components: CMSIS:CORE 5.0.1
